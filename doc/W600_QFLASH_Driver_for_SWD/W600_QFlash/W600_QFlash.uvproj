# Keil uVision project W600_QFlash.uvproj, settings and files
target W600_QFlash (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: W600
  AfterMake: cmd.exe /C copy W600.axf ..\W600_QFlash.FLM
  c flags: Optim=3
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
