# IAR project WM_W600.ewp, settings and files
configuration W60X SDK Project (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; WM_W600; __inline=inline; __inline__=inline; _CTYPE
  ICCARM.CCIncludePath2: ..\..\..\include; ..\..\..\include\app; ..\..\..\include\driver; ..\..\..\include\net; ..\..\..\include\os; ..\..\..\include\platform; ..\..\..\include\wifi; ..\..\..\demo; ..\..\..\demo\console; ..\..\..\platform\inc; ..\..\..\platform\boot\iccarm; ..\..\..\platform\common\crypto; ..\..\..\platform\common\crypto\digest; ..\..\..\platform\common\crypto\keyformat; ..\..\..\platform\common\crypto\math; ..\..\..\platform\common\crypto\prng; ..\..\..\platform\common\crypto\pubkey; ..\..\..\platform\common\crypto\symmetric; ..\..\..\platform\common\params; ..\..\..\platform\common\fwup; ..\..\..\platform\common\mem; ..\..\..\platform\common\utils; ..\..\..\src\network\lwip2.0.3\include; ..\..\..\src\os\rtos\include; ..\..\..\src\app\polarssl\include; ..\..\..\src\app\matrixssl; ..\..\..\src\app\matrixssl\core; ..\..\..\src\app\libcoap\include; ..\..\..\src\app\iperf; ..\..\..\src\app\ota; ..\..\..\src\app\dhcpserver; ..\..\..\src\app\dnsserver; ..\..\..\src\app\httpclient; ..\..\..\src\app\libcoap\include; ..\..\..\src\app\libwebsockets-2.1-stable; ..\..\..\src\app\ping; ..\..\..\src\app\wm_atcmd; ..\..\..\src\app\web; ..\..\..\src\app\mqtt; ..\..\..\src\network\api; ..\..\..\src\app\mdns\mdnscore; ..\..\..\src\app\mdns\mdnsposix; ..\..\..\platform\boot\iccarm
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WM_W600.bin
  postbuild: makeimg.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: w60x.out
  ILINK.IlinkIcfFile: link_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group main
    ../../../app/: main.c
  group cjson
    ../../../src/app/cjson/: cjson.c
  group cmd
    ../../../src/app/wm_atcmd/: wm_rmms.c wm_cmdp.c wm_cmdp_hostif.c wm_cmdp_ri.c wm_hspi_task.c wm_uart_task.c
  group demo
    ../../../demo/: wm_7816_demo.c wm_adc_demo.c wm_alljoyn_led_demo.c wm_apsta_demo.c Wm_cloud_demo.c wm_connect_net_demo.c wm_crypt_demo.c wm_crypt_hard_demo.c wm_dlna_mediarender_demo.c wm_dlna_mediarender_demo_vs1053.c wm_flash_demo.c wm_gpio_demo.c wm_http_demo.c wm_i2c_demo.c wm_i2s_demo.c wm_iperf_auto_demo.c wm_master_spi_demo.c wm_mcast_demo.c wm_ntp_demo.c wm_pmu_demo.c wm_pwm_demo.c wm_raw_socket_client_demo.c wm_raw_socket_server_demo.c wm_rsa_demo.c wm_rtc_demo.c wm_scan_demo.c wm_slave_spi_demo.c wm_socket_client_demo.c wm_socket_fwup_demo.c wm_socket_server_demo.c wm_socket_server_sel_demo.c wm_softap_demo.c wm_ssl_server_demo.c wm_timer_demo.c wm_uart_demo.c wm_udp_demo.c wm_websockets_demo.c wm_wps_demo.c
    ../../../demo/console/: wm_demo_console_task.c
  group dhcpserver
    ../../../src/app/dhcpserver/: dhcp_server.c
  group dnsserver
    ../../../src/app/dnsserver/: dns_server.c
  group httpClient
    ../../../src/app/httpclient/: HTTPClient.c HTTPClientAuth.c HTTPClientString.c HTTPClientWrapper.c wm_httpclient_task.c
  group iperf
    ../../../src/app/iperf/: iperf_api.c iperf_client_api.c iperf_error.c iperf_locale.c iperf_main.c iperf_net.c iperf_server_api.c iperf_tcp.c iperf_timer.c iperf_udp.c iperf_units.c iperf_util.c tcp_info.c tcp_window_size.c wm_perf.c
  group libcoap
    ../../../src/app/libcoap/: address.c async.c block.c coap_io_lwip.c coap_time.c debug.c encode.c hashkey.c mem_libcoap.c net.c option.c pdu.c resource.c str.c subscribe.c uri_libcoap.c
  group lwip
    ../../../src/network/api2.0.3/: tls_sockets.c tls_netconn.c
    ../../../src/network/lwip2.0.3/core/: def.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c inet_chksum.c ip.c timeouts.c alg.c
    ../../../src/network/lwip2.0.3/core/ipv4/: ip4_frag.c ip4_addr.c ip4.c dhcp.c etharp.c igmp.c icmp.c autoip.c
    ../../../src/network/lwip2.0.3/core/ipv6/: ip6_frag.c ip6_addr.c ip6.c dhcp6.c ethip6.c icmp6.c inet6.c mld6.c nd6.c
    ../../../src/network/lwip2.0.3/: sys_arch.c
    ../../../src/network/lwip2.0.3/netif/: ethernetif.c ethernet.c wm_ethernet.c
    ../../../src/network/lwip2.0.3/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
  group matrixssl
    ../../../src/app/matrixssl/: cipherSuite.c hsHash.c matrixssl.c matrixsslApi.c prf.c psk.c sslDecode.c sslEncode.c sslv3.c tls.c
    ../../../src/app/matrixssl/core/: corelib.c osdep.c
  group mdns
    ../../../src/app/mdns/mdnscore/: mdns.c
    ../../../src/app/mdns/mdnsposix/: mDNSPosix.c
  group mqtt
    ../../../src/app/mqtt/: libemqtt.c
  group ntp
    ../../../src/app/ntp/: ntp_client.c
  group oneshotcfg
    ../../../src/app/oneshotconfig/: libairkiss_log.lib wm_oneshot_airkiss.c wm_oneshot_lsd.c wm_wifi_oneshot.c
  group os
    ../../../src/os/rtos/: wm_osal_rtos.c
    ../../../src/os/rtos/source/: tasks.c rtostimers.c queue.c list.c heap_3.c heap_2.c croutine.c
    ../../../src/os/rtos/ports_iar/: port_m3_iar.c
  group ota
    ../../../src/app/ota/: wm_http_fwup.c wm_socket_fwup.c
  group ping
    ../../../src/app/ping/: ping.c
  group platform
    ../../../platform/boot/iccarm/: misc.c port_iar.s retarget_iar.c startup_iar.s
    ../../../platform/sys/: tls_sys.c wm_main.c
    ../../../platform/common/fwup/: wm_fwup.c
    ../../../platform/common/task/: wm_wl_mbox.c wm_wl_task.c wm_wl_timers.c
    ../../../platform/common/utils/: utils.c
    ../../../platform/common/crypto/: wm_crypto_hard.c
    ../../../platform/common/crypto/digest/: hmac.c md2.c md4.c sha224.c sha384.c sha512.c
    ../../../platform/common/crypto/keyformat/: asn1.c keyformat_base64.c x509.c
    ../../../platform/common/crypto/math/: pstm_mul_comba.c
    ../../../platform/common/crypto/prng/: prng.c yarrow.c
    ../../../platform/common/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c pubkey_rsa.c
    ../../../platform/common/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
    ../../../platform/common/mem/: wm_mem.c
    ../../../platform/common/Params/: wm_param.c
    ../../../platform/drivers/: wm_uart.c wm_timer.c wm_hostspi.c wm_rtc.c wm_pwm.c wm_irq.c wm_i2c.c wm_hspi.c wm_gpio.c wm_efuse.c wm_dma.c wm_cpu.c wm_adc.c wm_io.c wm_i2s.c wm_lcd.c wm_pmu.c wm_7816.c wm_internal_fls.c wm_fls.c wm_fls_gd25qxx.c wm_watchdog.c wm_gpio_afsel.c
  group polarssl
    ../../../src/app/polarssl/library/: arc4.c asn1parse.c base64.c cipher.c cipher_wrap.c error.c md.c md_wrap.c pem.c polarssl_bignum.c polarssl_debug.c polarssl_md5.c polarssl_sha1.c rsa.c ssl_cli.c ssl_tls.c x509parse.c
  group sslserver
    ../../../src/app/sslserver/: wm_ssl_server.c
  group webserver
    ../../../src/app/web/: fs.c httpd.c web.c
  group websocket
    ../../../src/app/libwebsockets-2.1-stable/: base64-decode.c client-handshake.c client-parser.c client.c context.c handshake.c header.c libwebsockets.c lws-plat-wm.c output.c parsers.c pollfd.c service.c ssl-client.c ssl.c
  group wlan_lib
    ../../../lib/: libwlan_iar.a
