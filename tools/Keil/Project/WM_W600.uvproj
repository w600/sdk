# Keil uVision project WM_W600.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: WM_W600 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: makeimg.bat
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: WM_W600
  c misc: --c99 --gnu
  c include: ..\..\..\Include;..\..\..\Src\Network\api;..\..\..\Src\Wlan\Driver;..\..\..\Src\Wlan\Supplicant;..\..\..\Platform\Common\Params;..\..\..\Platform\Common\task;..\..\..\Platform\Common\mem;..\..\..\Platform\Common\fwup;..\..\..\Platform\Common\utils;..\..\..\Platform\Inc;..\..\..\Platform\Sys;..\..\..\Src\App\wm_atcmd;..\..\..\Src\App\demo;..\..\..\Src\App\dhcpserver;..\..\..\Src\App\dnsserver;..\..\..\Src\App\matrixssl;..\..\..\Src\App\matrixssl\crypto;..\..\..\Src\App\libupnp-1.6.19\ixml\inc;..\..\..\Src\App\libupnp-1.6.19\upnp\inc;..\..\..\Src\App\libupnp-1.6.19\ixml\include;..\..\..\Src\App\libupnp-1.6.19\threadutil\include;..\..\..\Src\App\libupnp-1.6.19\upnp\include;..\..\..\Src\App\gmediarender-0.0.6;..\..\..\Src\App\web;..\..\..\Src\App\cloud;..\..\..\Src\App\cJSON;..\..\..\Src\App\ajtcl-15.04.00a\inc;..\..\..\Src\App\ajtcl-15.04.00a\target\winnermicro;..\..\..\Src\App\ajtcl-15.04.00a\external\sha2;..\..\..\Src\App\cJSON;..\..\..\Src\App\cloud\Kii;..\..\..\Src\App\rmms;..\..\..\Demo;..\..\..\Src\App\ntp;..\..\..\Src\OS\OS_ports;..\..\..\Src\App\httpclient;..\..\..\Src\App\oneshotconfig;..\..\..\Lib;..\..\..\Src\App\iperf;..\..\..\Src\OS\uCOS-II;..\..\..\Src\OS\uCOS-II\ports;..\..\..\Src\OS\uCOS-II\source;..\..\..\Src\OS\RTOS\include;..\..\..\Platform\Common\crypto;..\..\..\Include\App;..\..\..\Include\Driver;..\..\..\Include\Net;..\..\..\Include\OS;..\..\..\Include\Platform;..\..\..\Include\WiFi;..\..\..\Src\App\matrixssl\core;..\..\..\Platform\Common\crypto\digest;..\..\..\Platform\Common\crypto\math;..\..\..\Platform\Common\crypto\symmetric;..\..\..\Src\App\mqtt;..\..\..\Src\App\iperf;..\..\..\Src\App\ping;..\..\..\Src\App\polarssl\include;..\..\..\Src\App\mDNS\mDNSPosix;..\..\..\Src\App\mDNS\mDNSCore;..\..\..\Src\Network\lwip2.0.3\include;..\..\..\Src\App\OTA;..\..\..\Src\App\libwebsockets-2.1-stable;..\..\..\Platform\Common\crypto
  asm include: ..\..\..\Include\OS
  library: MicroLIB
  memory RVCT4: ROM 0x8010100 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group main
    ../../../App/: main.c
  group Demo
    ../../../demo/: wm_7816_demo.c wm_adc_demo.c wm_alljoyn_led_demo.c wm_apsta_demo.c Wm_cloud_demo.c wm_connect_net_demo.c wm_crypt_demo.c wm_crypt_hard_demo.c wm_dlna_mediarender_demo.c wm_dlna_mediarender_demo_vs1053.c wm_flash_demo.c wm_gpio_demo.c wm_http_demo.c wm_i2c_demo.c wm_i2s_demo.c wm_iperf_auto_demo.c wm_master_spi_demo.c wm_mcast_demo.c wm_ntp_demo.c wm_pmu_demo.c wm_pwm_demo.c wm_raw_socket_client_demo.c wm_raw_socket_server_demo.c wm_rsa_demo.c wm_rtc_demo.c wm_scan_demo.c wm_slave_spi_demo.c wm_socket_client_demo.c wm_socket_fwup_demo.c wm_socket_server_demo.c wm_socket_server_sel_demo.c wm_softap_demo.c wm_ssl_server_demo.c wm_timer_demo.c wm_uart_demo.c wm_udp_demo.c wm_websockets_demo.c wm_wps_demo.c
    ../../../demo/console/: wm_demo_console_task.c
  group Platform
    ../../../Platform/Boot/armcc/: retarget.c misc.c
    ../../../Platform/Sys/: wm_main.c tls_sys.c
    ../../../platform/drivers/: wm_7816.c wm_adc.c wm_cpu.c wm_dma.c wm_efuse.c wm_fls.c wm_fls_gd25qxx.c wm_gpio.c wm_gpio_afsel.c wm_hostspi.c wm_hspi.c wm_i2c.c wm_i2s.c wm_internal_fls.c wm_io.c wm_iouart.c wm_irq.c wm_lcd.c wm_pmu.c wm_pwm.c wm_reflector.c wm_rtc.c wm_timer.c wm_uart.c wm_watchdog.c
    ../../../platform/common/crypto/: wm_crypto_hard.c
    ../../../platform/common/crypto/digest/: hmac.c md2.c md4.c sha224.c sha384.c sha512.c
    ../../../platform/common/crypto/keyformat/: asn1.c x509.c keyformat_base64.c
    ../../../platform/common/crypto/math/: pstm_mul_comba.c
    ../../../platform/common/crypto/prng/: prng.c yarrow.c
    ../../../platform/common/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c pubkey_rsa.c
    ../../../platform/common/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
    ../../../platform/boot/armcc/: startup.s
    ../../../platform/common/params/: wm_param.c
    ../../../platform/common/fwup/: wm_fwup.c
    ../../../platform/common/mem/: wm_mem.c
    ../../../platform/common/task/: wm_wl_mbox.c wm_wl_task.c wm_wl_timers.c
    ../../../platform/common/utils/: utils.c
  group DhcpServer
    ../../../Src/App/dhcpserver/: dhcp_server.c
  group DnsServer
    ../../../Src/App/dnsserver/: dns_server.c
  group oneshotcfg
    ../../../Src/App/oneshotconfig/: wm_wifi_oneshot.c wm_oneshot_airkiss.c wm_oneshot_lsd.c
    ../../../lib/: libairkiss_log.lib
  group Cmd
    ../../../src/app/wm_atcmd/: wm_cmdp.c wm_cmdp_hostif.c wm_cmdp_ri.c wm_hspi_task.c wm_rmms.c wm_uart_task.c
  group OS
    ../../../src/os/rtos/: wm_osal_rtos.c
    ../../../src/os/rtos/source/: croutine.c heap_2.c heap_3.c list.c queue.c rtostimers.c tasks.c
    ../../../src/os/rtos/ports/: port_m3.c
  group LWIP
    ../../../src/network/api2.0.3/: tls_netconn.c tls_sockets.c
    ../../../src/network/lwip2.0.3/: sys_arch.c
    ../../../src/network/lwip2.0.3/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ../../../src/network/lwip2.0.3/core/: alg.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../src/network/lwip2.0.3/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../src/network/lwip2.0.3/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../src/network/lwip2.0.3/netif/: ethernet.c ethernetif.c wm_ethernet.c
  group NTP
    ../../../Src/App/ntp/: ntp_client.c
  group websocket
    ../../../Src/App/libwebsockets-2.1-stable/: base64-decode.c client.c client-handshake.c client-parser.c context.c handshake.c header.c libwebsockets.c lws-plat-wm.c output.c parsers.c pollfd.c service.c ssl.c ssl-client.c
  group libcoap
    ../../../Src/App/libcoap/: address.c async.c block.c coap_time.c debug.c encode.c hashkey.c option.c pdu.c resource.c str.c subscribe.c uri_libcoap.c mem_libcoap.c coap_io_lwip.c net.c
  group cJSON
    ../../../Src/App/cJSON/: cJSON.c
  group HttpClient
    ../../../src/app/httpclient/: HTTPClient.c HTTPClientAuth.c HTTPClientString.c HTTPClientWrapper.c wm_httpclient_task.c
  group MQTT
    ../../../Src/App/mqtt/: libemqtt.c
  group PING
    ../../../Src/App/ping/: ping.c
  group MatrixSSL
    ../../../src/app/matrixssl/: cipherSuite.c hsHash.c matrixssl.c matrixsslApi.c prf.c psk.c sslDecode.c sslEncode.c sslv3.c tls.c
    ../../../src/app/matrixssl/core/: corelib.c osdep.c
  group Iperf
    ../../../Src/App/iperf/: iperf_api.c iperf_client_api.c iperf_error.c iperf_locale.c iperf_main.c iperf_net.c iperf_server_api.c iperf_tcp.c iperf_timer.c iperf_udp.c iperf_units.c iperf_util.c tcp_info.c tcp_window_size.c wm_perf.c
  group polarssl
    ../../../Src/App/polarssl/library/: asn1parse.c base64.c cipher.c cipher_wrap.c error.c md.c md_wrap.c pem.c rsa.c ssl_cli.c ssl_tls.c x509parse.c polarssl_bignum.c polarssl_debug.c polarssl_md5.c polarssl_sha1.c arc4.c
  group mDNS
    ../../../Src/App/mDNS/mDNSPosix/: mDNSPosix.c
    ../../../Src/App/mDNS/mDNSCore/: mDNS.c
  group wlan_lib
    ../../../lib/: libwlan.lib
  group OTA
    ../../../Src/App/OTA/: wm_http_fwup.c wm_socket_fwup.c
  group SSLServer
    ../../../Src/App/sslserver/: wm_ssl_server.c
  group WebServer
    ../../../Src/App/web/: fs.c httpd.c web.c
